# Keil uVision project F103Proj_Zhukong.uvprojx, settings and files
target F103Proj_Zhukong (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: release +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin -o ../Output/release.bin ../Output/release.axf
  AfterMake: CopyHex.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWLIB\inc;..\User;..\..\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c Test_main.c
    ../../BSP/: bsp_common.c bsp_common.h bsp_delay.c bsp_delay.h bsp_gpio.c bsp_gpio.h bsp_usart.c bsp_usart.h bsp_timer.c bsp_timer.h bsp_coin.c bsp_coin.h bsp_zhibiqi.c bsp_zhibiqi.h bsp_yingbiqi.c bsp_yingbiqi.h
target Zhukong_TEST (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: release +hex
  AfterMake: as above
  AfterMake: CopyHex.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWLIB\inc;..\User;..\..\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
